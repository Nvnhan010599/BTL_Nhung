# Keil uVision project BTL_Nhung.uvprojx, settings and files
target PWM_ENC_UART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo_UART
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000
  c include: ..\BTL_Nhung;.\STM32F4xx_StdPeriph_Driver\inc;..\BTL_Nhung
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c system_stm32f4xx.c startup_stm32f40_41xxx.s stm32f4xx_it.c system_timetick.c Encoder.c PID.c PWM.c UART.c
  group STM32F4
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_gpio.c stm32f4xx_tim.c misc.c stm32f4xx_dma.c
software components: CMSIS:CORE 5.3.0
